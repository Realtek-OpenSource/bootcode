## configs/rtd1295_fpga_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_RTD1295=y
CONFIG_BOARD_FPGA=y
CONFIG_SYS_MALLOC_CLEAR_ON_INIT=y
```
